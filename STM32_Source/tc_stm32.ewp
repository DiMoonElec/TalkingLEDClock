# IAR project tc_stm32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; CMSIS\; System\; fsm\; fsm\core\; drv\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tc_stm32.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: flash_stm32f103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: crc16.c crc16.h loader.c loader.h main.c params.c params.h rtc.c rtc.h watch_io.c watch_io.h
  group CMSIS
    CMSIS/: core_cm3.h core_cmFunc.h core_cmInstr.h startup_stm32f103xb.s stm32f103xb.h stm32f1xx.h system_stm32f1xx.c system_stm32f1xx.h
  group drv
    drv/: at45db321.c at45db321.h light_sensor.c light_sensor.h media.c media.h pwr_sourse.c pwr_sourse.h spi.c spi.h temper.c temper.h uart.c uart.h voice.c voice.h voice_table.h
  group fsm
    fsm/: fsm_main.c fsm_main.h
  group fsm/core
    fsm/core/: messages.c messages.h signals.c signals.h timers.c timers.h
  group System
    System/: clock.c clock.h
